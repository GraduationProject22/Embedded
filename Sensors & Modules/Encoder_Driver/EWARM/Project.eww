<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\20220425_Encoder_Driver_Test.ewp</path>
  </project>
  <batchBuild />
</workspace>

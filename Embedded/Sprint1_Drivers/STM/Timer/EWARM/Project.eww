<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\20220306_Timer_Test_1.ewp</path>
    </project>
    <batchBuild />
</workspace>
